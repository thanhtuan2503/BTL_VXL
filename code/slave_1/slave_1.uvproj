# Keil uVision project slave_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: slave_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: slave_1.asm
